BO_ MessageName : 8 Vector__XXX
BO_ 1234  : 8 Vector__XXX
BO_ 1234 MessageName : Vector__XXX
BO_ 1234 MessageName : 8
